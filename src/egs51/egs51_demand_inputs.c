/* A0215451432 bank0 BA18..BFD4: upstream qualification and demand staging.
 * These consume decoded OEM signals, not live NAG52 sensor encodings. */
#include "egs51_internal.h"
void egs51_vehicle_flags(Egs51 *s) { /* BA18..BC49 */
    uint8_t faults=X(0x71);
    X(0x1c5)&=0xdf; X(0x1cb)&=0xdf;
    if(faults&0x18) { X(0x8d)=0; X(0x8e)=0; X(0x1cb)|=0x20; }
    else if(X(0x91)&2) X(0x1cb)|=0x20;
    else flag(&X(0x1c5),0x20,X(0x91)&1);
    X(0x1c7)=(uint8_t)((X(0x1c7)&0xf8)|((X(0x8e)>>2)&7));
    if(faults&0x28) { X(0x96)=0; X(0x98)=0; X(0x7d)=0; X(0x7f)=0; X(0x80)=0; }
    if(faults&0x48) X(0x8c)=0;
    flag(&X(0x1c5),1,(X(0x96)&0x20)||(X(0x8d)&0x40));
    flag(&X(0x1c5),2,(X(0x96)&0x40)||(X(0x8d)&0x80));
    X(0x328)=X(0x7f)>>4;
    flag(&X(0x1c5),4,X(0x7d)&1); flag(&X(0x1c5),8,X(0x7d)&8); flag(&X(0x1c5),0x10,X(0x7d)&0x20);
    flag(&X(0x1c7),8,X(0x96)&0x10); flag(&X(0x1c7),0x10,X(0x98)&0x10);
    flag(&X(0x1c8),8,X(0x8c)&1); flag(&X(0x1c8),0x10,X(0x98)&2);
    flag(&X(0x1c7),0x20,X(0x7d)&0x40); flag(&X(0x1c8),0x40,X(0x80)&1);
    if(X(0x183)!=2) return;
    XP(0x203,XW(0x17f)); X(0x1c5)&=0xbf; X(0x1c8)&=0xdf; X(0x1cb)&=0xbf;
    if(faults&0x88) { X(0x1cb)|=0x40; return; }
    if(X(0x9c)&1) { X(0x1c5)|=0x40; XP(0x203,md(XW(0x17f),BW(0xff97),100)); }
    else if(!(X(0x9c)&2)) X(0x1c8)|=0x20;
}
void egs51_pedal_inputs(Egs51 *s) { /* BC4A..BD4F */
    uint8_t pedal=I(0x86);
    if((X(0x1c8)&0x10) && pedal>B(0xff88)) pedal=B(0xff88);
    X(0x1ca)&=0xfe;
    if((X(0x71)&0x28) || (X(0x70)&1)) { X(0x1ca)|=1; pedal=B(0xff02); }
    X(0x285)=(uint8_t)md(pedal,4,10);
    uint16_t delta=(uint16_t)(100u*(uint16_t)(pedal-X(0x34f)));
    X(0x34f)=pedal;
    uint8_t weight=B(0xff89);
    XP(0x39b,(signed16(XW(0x39b))*weight+signed16(delta))/(weight+1));
    XP(0x224,egs51_signed_md(XW(0x39b),4,20));
    flag(&X(0x1c5),0x80,(I(0x20)&1) && pedal>=B(0xff87));
    X(0x2de)=X(0x7b);
    if(X(0x184)==3) X(0x2de)=X(0x285);
    else if((X(0x71)&0x28) || (X(0x70)&0x80)) X(0x2de)=B(0xff44);
}
void egs51_target_step(Egs51 *s) { /* BD50..BE8D */
    flag(&X(0x1cb),0x80,(X(0x6f)&1)||(X(0x6e)&0x80));
    if(X(0x75)>X(0x334)) X(0x334)++;
    else if(X(0x75)<X(0x334)) X(0x334)--;
    uint8_t target=X(0x334);
    if(target==6 || target==8) X(0x1e8)=target;
    flag(&X(0x1c6),0x80,I(0x20)&4);
    flag(&X(0x1c6),1,X(0x1c6)&0x80);
    if(X(0x1c8)&0x10) X(0x1c6)&=0xfe;
    if(X(0x183)==2) {
        if(X(0x1c5)&0x40) X(0x1c6)|=0x85;
        else X(0x1c6)&=0x7a;
        return;
    }
    int mismatch=(X(0x1c6)&1)!=((X(0x1c6)>>2)&1);
    if(target==7) { if(mismatch) X(0x1c6)|=2; }
    else if(!(X(0x1c6)&2)) flag(&X(0x1c6),4,X(0x1c6)&1);
    else if((target<=5 && !I(0xb6)) || ((target==6 || target==8) && !mismatch)) X(0x1c6)&=0xfd;
}
void egs51_aux_qualification(Egs51 *s) { /* BE8E..BEC2 */
    flag(&X(0x1ca),2,X(0x6f)&4);
    flag(&X(0x1ca),4,X(0x71)&12);
    if(X(0x71)&12) X(0x97)=B(0xff01);
}
void egs51_engine_inputs(Egs51 *s) { /* BEC3..BFD4 */
    X(0x1ca)&=0xf7; XP(0x275,IW(0x87));
    if((X(0x71)&0x28) || (X(0x70)&4)) { X(0x1ca)|=8; XP(0x275,BW(0xfefd)); }
    uint16_t next=(uint16_t)(XW(0x275)<<3),old=(uint16_t)(XW(0x340)<<3);
    uint8_t weight=B(0xff8e);
    XP(0x340,((uint32_t)old*weight+next)/(weight+1u)/8u);
    if(!(X(0x1c6)&0x10)) {
        if(XW(0x275)<BW(0xff8b)) X(0x216)=(uint8_t)(4u*B(0xff8d));
        else if(!X(0x216) || (X(0x216)<=(uint8_t)(3u*B(0xff8d)) && (X(0x334)==7 || X(0x334)<=5))) X(0x1c6)|=0x10;
    }
    flag(&X(0x1c6),8,XW(0x275)>=BW(0xffae));
}

static uint16_t input_filter(uint16_t old,uint16_t next,uint8_t weight) {
    return (uint16_t)(((uint32_t)old*weight+next)/(weight+1u));
}
static uint16_t input_abs(uint16_t value) { return signed16(value)<0?(uint16_t)(0-value):value; }
void egs51_wheel_inputs(Egs51 *s) { /* BFD5..C448 */
    X(0x1ca)&=0x0f; X(0x1cb)&=0xfc; X(0x1bb)&=0xfd;
    static const uint16_t source[]={0x87,0x89,0x81,0x84};
    static const uint16_t dest[]={0x332,0x349,0x314,0x323};
    for(unsigned k=0;k<4;k++) {
        uint16_t value=XW(source[k]);
        if(value>BW(0xff99)) { value=BW(0xff99); X(0x1bb)|=2; }
        XP(dest[k],value);
    }
    if(X(0x71)&0x18) { X(0x1ca)|=0xf0; X(0x1cb)|=1; }
    else {
        unsigned count=0;
        if(X(0x6f)&0x10) { X(0x1ca)|=0x20; XP(0x349,XW(0x332)); count++; }
        if(X(0x6f)&0x20) { X(0x1ca)|=0x10; XP(0x332,XW(0x349)); count++; }
        if(X(0x6f)&0x40) { X(0x1ca)|=0x80; XP(0x323,XW(0x314)); count++; }
        if(X(0x6f)&0x80) { X(0x1ca)|=0x40; XP(0x314,XW(0x323)); count++; }
        if((X(0x1ca)&0xc0)==0xc0) { XP(0x323,BW(0xfeff)); XP(0x314,BW(0xfeff)); }
        if((X(0x1ca)&0x30)==0x30 || (count>1 && X(0x183))) X(0x1cb)|=1;
    }
    if(X(0x1cb)&1) {
        for(unsigned k=0;k<4;k++) XP(dest[k],BW(0xfeff));
        if(!(X(0x71)&8)) X(0x1cb)|=2;
    }
    XP(0x31e,input_filter(XW(0x31e),(uint16_t)(25u*XW(0x314)),B(0xff8f)));
    XP(0x33e,input_filter(XW(0x33e),(uint16_t)(25u*XW(0x323)),B(0xff8f)));
    uint16_t combined=(uint16_t)(md((uint16_t)(100-X(0x2c0)),(uint16_t)(XW(0x323)+XW(0x314)),8)+
                                  md(X(0x2c0),(uint16_t)(XW(0x349)+XW(0x332)),8));
    XP(0x375,md(combined,XW(0x203),2500));
    XP(0x2ef,input_filter(XW(0x2ef),combined,B(0xff91)));
    XP(0x2ac,md(XW(0x2ef),XW(0x203),2500));
    XP(0x29a,md(XW(0x2ef),XW(0x181),0xa2c3));
    XP(0x2d4,md(XW(0x2cc),XW(0x181),0xa2c3));
    if((X(0x1ca)&0xc0)==0xc0) XP(0x2d4,XW(0x29a));
    flag(&X(0x1c7),0x80,input_abs((uint16_t)(XW(0x332)-XW(0x349)))>BW(0xffb0) ||
                             input_abs((uint16_t)(XW(0x314)-XW(0x323)))>BW(0xffb0));
    XP(0x270,md(XW(0x203),0x683,XW(0x181)));
    if(XW(0x2ac)<=BW(0xff93)) X(0x1c6)|=0x20;
    else if(XW(0x2ac)>=BW(0xff95)) X(0x1c6)&=0xdf;
}

void egs51_shaft_inputs(Egs51 *s) { /* C496..C6C5 */
    I(0x23)&=0xf3; X(0x1cb)&=0xfb;
    uint16_t threshold=BW(0xff14);
    int qualified=(X(0x1c6)&8) && !(X(0x1ca)&0x38) && !(X(0x78)&8) && !(X(0x1cb)&1) &&
        XW(0x87)>=threshold && XW(0x89)>=threshold &&
        (X(0x183)>2 || (XW(0x323)>=threshold && XW(0x314)>=threshold)) && !(X(0x1c7)&0x80);
    if(X(0x6e)&2) { X(0x1cb)|=4; XP(0x1f0,BW(0xfefb)); XP(0x1f6,BW(0xfefb)); }
    else {
        if(X(0x6e)&4) { X(0x1cb)|=4; XP(0x1f0,BW(0xfefb)); }
        else {
            /* 0BF3 only stores helper scratch; no hardware side effect. */
            if((B(0xfef4)&4) && qualified && !IW(0x81)) I(0x23)|=4;
            if(!(I(0x23)&4)) XP(0x1f0,IW(0x81));
        }
        if(X(0x6e)&8) { X(0x1cb)|=4; XP(0x1f6,BW(0xfefb)); }
        else {
            if((B(0xfef4)&8) && qualified && !I(0xb6) &&
               (X(0x34c)==3 || X(0x34c)==4) && X(0x34c)==I(0xb9) && !IW(0x83)) I(0x23)|=8;
            if(!(I(0x23)&8)) XP(0x1f6,IW(0x83));
        }
    }
    I(0x23)&=0xef;
    if(X(0x6e)&0x10) { X(0x1cb)|=4; XP(0x1f0,BW(0xfefb)); XP(0x1f6,BW(0xfefb)); }
    else if((B(0xfef4)&0x10) && !I(0xb6) && qualified && IW(0x83)>BW(0xfef7) &&
            input_abs((uint16_t)(IW(0x81)-IW(0x83)))>=BW(0xfef9)) I(0x23)|=0x10;
    if(X(0x1cb)&4) XP(0x22f,BW(0xfefb));
}

void egs51_gear_qualification(Egs51 *s) { /* 920F..9537 */
    I(0xa9)=I(0xab);
    uint8_t target=X(0x334);
    if(target<=5) {
        uint8_t gear=X(0x227);
        if(gear>1) {
            if((I(0xb6) && (I(0xaa) || !(I(0x95)&0x10))) || (X(0x1ca)&8)) {
                uint16_t speed=XW(0x2ac);
                if(!(X(0x1ca)&8) && XW(0x21c)>speed) speed=XW(0x21c);
                XP(0x391,md(speed,BW(0x103e + 2*gear),1000)+100u);
            } else {
                uint8_t denominator=(uint8_t)(gear+(!I(0xaa) && (I(0x95)&0x10)?1:0));
                XP(0x391,md(XW(0x275),BW(0x103e + 2*gear),BW(0x1040+2*denominator)));
                XP(0x21c,md((uint16_t)(XW(0x275)-100),1000,BW(0x1040+2*denominator)));
            }
        }
        if(I(0xab)<I(0xb9) && XW(0x21c)>BW(XW(0x3a8)+0x11+2*X(0x2eb)) && !(X(0x1c5)&0x80)) I(0xa9)=I(0xb9);
        if(target<I(0xb9) && I(0xab)>=I(0xb9)) {
            if(target<X(0x300)) { X(0x1bd)&=0xfb; X(0x300)=target; }
            if(X(0x78)&2) X(0x1bd)|=4;
            if(!(X(0x1bd)&4) && XW(0x391)<BW(XW(0x3a8)+1)) I(0xa9)=(uint8_t)(I(0xb9)-1);
            else { I(0xa9)=I(0xb9); X(0x300)=target; X(0x1bd)|=4; }
        } else if(target>=I(0xb9)) {
            X(0x1bd)&=0xfb;
            if(target<I(0xab) && !(I(0x9a)&0x10)) I(0xa9)=I(0xb9);
        }
    } else X(0x1bd)&=0xfb;
    if(I(0x9a)&4) {
        if(XW(0x2ef)<BW(0xfc3e) || target==7) {
            uint16_t descriptor=BW(XW(0x3aa)+((X(0x1c6)&4)?0x10:0));
            I(0xab)=B(BW(descriptor+4))?1:2;
        } else I(0xab)=5;
        I(0xa9)=I(0xab);
    }
    if(target==7) {
        if(I(0xab)==1) I(0xa9)=6;
        else { I(0xa9)=7; I(0xab)=2; }
    } else if(target<=5) {
        if((X(0x1c2)&4) && I(0xb9)<=3 && I(0xb6)!=5 && I(0xb6)!=6) I(0xa9)=3;
    } else I(0xa9)=0;
}
